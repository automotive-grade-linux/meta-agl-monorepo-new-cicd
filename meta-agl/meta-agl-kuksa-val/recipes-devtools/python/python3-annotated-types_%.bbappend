require ${@bb.utils.contains('AGL_FEATURES', 'agl-kuksa-val', 'python3-annotated-types_agl-kuksa-val.inc', '', d)}
