require ${@bb.utils.contains('AGL_FEATURES', 'agl-drm-lease', 'qtbase_agl-drm-lease.inc', '', d)}
