SRC_URI:remove = "git://strlcat.eu/mirroring/jh7110_soft_3rdpart.git;protocol=https;branch=JH7110_VisionFive2_devel"
SRC_URI:prepend = "git://github.com/starfive-tech/soft_3rdpart.git;protocol=https;lfs=1;branch=JH7110_VisionFive2_devel "
