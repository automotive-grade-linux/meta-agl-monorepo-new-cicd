# Remove apparently accidental dependency to avoid dependency loops
# with e.g. pipewire
DEPENDS:remove = "libsdl2"
