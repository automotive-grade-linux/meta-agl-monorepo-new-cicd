# RaspberryPI is fource disabling cgroup.memory at default.  It's re-enabling to cgroup.memory.
CMDLINE:append = " cgroup_enable=memory"
