FILESEXTRAPATHS:prepend:rk3588 := "${THISDIR}/${PN}:"

PACKAGE_ARCH:rk3588 = "${MACHINE_ARCH}"
