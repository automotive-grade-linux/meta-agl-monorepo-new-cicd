require ${@bb.utils.contains('AGL_FEATURES', 'aglcore', 'linux-yocto-agl.inc', '', d)}
