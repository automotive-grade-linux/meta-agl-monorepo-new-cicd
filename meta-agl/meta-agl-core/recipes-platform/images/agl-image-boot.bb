SUMMARY = "A small image just capable of allowing a device to boot."
LICENSE = "MIT"

inherit agl-core-image

