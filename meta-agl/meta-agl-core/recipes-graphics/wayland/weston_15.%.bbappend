require ${@bb.utils.contains('AGL_FEATURES', 'aglcore', 'weston_15_aglcore.inc', '', d)}
