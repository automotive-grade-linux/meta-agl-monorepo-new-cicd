require ${@bb.utils.contains('AGL_FEATURES', 'agl-drm-lease', 'agl-compositor-init_agl-drm-lease.inc', '', d)}

