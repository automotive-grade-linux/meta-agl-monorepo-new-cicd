do_configure:append:bbe() {
    echo 'gbm-format=rgb565' >> ${WORKDIR}/core.cfg
}
