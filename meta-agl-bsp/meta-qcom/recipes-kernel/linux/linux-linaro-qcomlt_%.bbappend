require recipes-kernel/linux/linux-agl-config.inc
