# Use provided hook to disable removal of wayland from PACKAGECONFIG
PACKAGECONFIG_IMX_REMOVALS = "x11"
