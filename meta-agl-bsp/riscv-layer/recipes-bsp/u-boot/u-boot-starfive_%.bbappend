FILESEXTRAPATHS:prepend := "${THISDIR}/u-boot-starfive:"
