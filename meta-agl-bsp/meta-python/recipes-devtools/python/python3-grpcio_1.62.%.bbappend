FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

SRC_URI += "file://0001-PR-1644-unscaledcycleclock-remove-RISC-V-support.patch"
