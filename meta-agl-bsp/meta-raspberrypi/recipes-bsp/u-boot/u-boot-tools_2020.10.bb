require recipes-bsp/u-boot/u-boot-tools_2020.01.bb
require u-boot-2020.10.inc
