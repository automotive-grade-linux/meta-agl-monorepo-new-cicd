require recipes-bsp/u-boot/u-boot_2020.01.bb
require u-boot-2020.10.inc
