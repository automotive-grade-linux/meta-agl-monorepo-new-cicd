require recipes-bsp/u-boot/u-boot_2020.01.bb
require u-boot-2021.07.inc
