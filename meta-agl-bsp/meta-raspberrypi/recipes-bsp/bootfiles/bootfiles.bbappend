RDEPENDS:${PN}:append:sota += " u-boot-otascript"
