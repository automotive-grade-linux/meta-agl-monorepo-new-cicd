# Disable faad by default to avoid licensing issues
PACKAGECONFIG:remove:rpi = "faad"
