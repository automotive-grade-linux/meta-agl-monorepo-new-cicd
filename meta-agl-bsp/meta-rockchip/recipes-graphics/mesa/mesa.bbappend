# Hopefully temporary workaround
INSANE_SKIP:${PN}-vulkan-drivers += "buildpaths"
INSANE_SKIP:${PN}-src += "buildpaths"
