FILESEXTRAPATHS:prepend:nanopc-t6 := "${THISDIR}/${PN}:"

PACKAGE_ARCH:nanopc-t6 = "${MACHINE_ARCH}"
