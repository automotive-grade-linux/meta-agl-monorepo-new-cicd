RDEPENDS:${PN} += "\
    gstreamer1.0-rockchip-rockchipmpp \
"

