require agl-ivi-demo-flutter-guest-preconfigured.bb

SUMMARY = "AGL KVM + gateway demo preconfigured guest IVI Flutter image"

KUKSA_CONF = "kuksa-conf-gateway-demo"
