require agl-cluster-demo-flutter-guest-preconfigured.bb

SUMMARY = "AGL KVM + gateway demo preconfigured guest cluster Flutter image"

KUKSA_CONF = "kuksa-conf-gateway-demo"
