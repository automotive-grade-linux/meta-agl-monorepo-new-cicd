RDEPENDS_${PN} += "nativesdk-low-level-can-generator \
		nativesdk-cmake-apps-module \
		nativesdk-cmake-apps-module-doc \
"
