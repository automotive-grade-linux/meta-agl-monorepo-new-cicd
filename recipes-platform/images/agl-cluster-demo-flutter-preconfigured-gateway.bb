require agl-cluster-demo-flutter-preconfigured.bb

SUMMARY = "AGL Cluster preconfigured gateway demo Flutter image"

# Application KUKSA configuration needs to be replaced for
# the full demo to handle different databroker configuration.
KUKSA_CONF = "kuksa-conf-gateway-demo"

