SUMMARY = "The middlewares for AGL IVI profile"
DESCRIPTION = "The set of packages required for identity services"
LICENSE = "MIT"

inherit packagegroup

ALLOW_EMPTY:${PN} = "1"

RDEPENDS:${PN} += "\
"

