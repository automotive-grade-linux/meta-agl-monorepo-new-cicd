require ${@bb.utils.contains('AGL_FEATURES', 'aglcore', 'weston_14_aglcore.inc', '', d)}
