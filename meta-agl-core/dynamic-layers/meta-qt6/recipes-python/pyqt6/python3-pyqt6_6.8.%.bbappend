require ${@bb.utils.contains('AGL_FEATURES', 'aglcore', 'python3-pyqt6_aglcore.inc', '', d)}
