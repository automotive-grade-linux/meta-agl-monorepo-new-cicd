require ${@bb.utils.contains('AGL_FEATURES', 'agl-kuksa-val', 'python3-pydantic-core_agl-kuksa-val.inc', '', d)}
