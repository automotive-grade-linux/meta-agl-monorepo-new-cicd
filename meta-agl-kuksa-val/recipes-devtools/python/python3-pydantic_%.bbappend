require ${@bb.utils.contains('AGL_FEATURES', 'agl-kuksa-val', 'python3-pydantic_agl-kuksa-val.inc', '', d)}
