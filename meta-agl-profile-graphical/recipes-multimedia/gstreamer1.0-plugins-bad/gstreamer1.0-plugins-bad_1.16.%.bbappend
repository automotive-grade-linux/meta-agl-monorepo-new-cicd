FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI_append=" file://0001-gst-wayland-Install-wayland-header-from-gstwayland-l.patch"
