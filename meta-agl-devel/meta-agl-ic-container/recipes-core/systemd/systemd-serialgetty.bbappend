# Disable getty service unit generation for guests
SERIAL_CONSOLES:aglcontainerguest = ""
