require agl-cluster-demo-flutter-tradeshow.bb

SUMMARY = "AGL Cluster tradeshow gateway demo Flutter image"

# Application KUKSA configuration needs to be replaced for
# the full demo to handle different databroker configuration.
KUKSA_CONF = "kuksa-conf-gateway-demo"

