require ${@bb.utils.contains('AGL_FEATURES', 'agldemo', 'weston_aglcore.inc', '', d)}
