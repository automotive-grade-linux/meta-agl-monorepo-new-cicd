require ${@bb.utils.contains('FLUTTER_CAMERA_STREAMS_ENABLE', '1', 'opencv_fluttercamerastreams.inc', '', d)}