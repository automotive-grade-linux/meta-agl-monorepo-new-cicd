require ${@bb.utils.contains('FLUTTER_CAMERA_STREAMS_ENABLE', '1', 'tensorflow-lite_fluttercamerastreams.inc', '', d)}