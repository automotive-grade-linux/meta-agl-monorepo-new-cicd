require agl-cluster-demo-flutter-guest-tradeshow.bb

SUMMARY = "AGL KVM + gateway demo tradeshow guest cluster Flutter image"

KUKSA_CONF = "kuksa-conf-gateway-demo"
