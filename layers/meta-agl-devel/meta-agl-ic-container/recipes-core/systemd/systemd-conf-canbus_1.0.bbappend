CANBUS_NETWORK_CONFIG:rcar-gen3 = "canbus-can-fd.network"
CANBUS_NETWORK_CONFIG:rcar-gen4 = "canbus-can-fd.network"
