PACKAGECONFIG:append = " gallium-llvm"

