require ${@bb.utils.contains('AGL_FEATURES', 'agl-kuksa-val', 'python3-rich_agl-kuksa-val.inc', '', d)}
