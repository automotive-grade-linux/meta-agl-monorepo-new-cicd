require ${@bb.utils.contains('AGL_FEATURES', 'agl-drm-lease', 'mesa_24_agl-drm-lease.inc', '', d)}
