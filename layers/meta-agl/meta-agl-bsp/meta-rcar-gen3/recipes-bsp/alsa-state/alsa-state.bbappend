FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

COMPATIBLE_MACHINE = "(m3ulcb|h3ulcb)"

PACKAGE_ARCH = "${MACHINE_ARCH}"

