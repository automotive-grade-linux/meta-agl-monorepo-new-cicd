FILESEXTRAPATHS:prepend := "${THISDIR}/linux-fitimage:"
