require ${@bb.utils.contains('AGL_FEATURES', 'agl-ic', 'dlt-daemon_agl-ic.inc', '', d)}
