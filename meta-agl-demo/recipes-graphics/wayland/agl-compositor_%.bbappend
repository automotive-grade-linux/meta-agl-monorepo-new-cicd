require ${@bb.utils.contains('AGL_FEATURES', 'agldemo', 'agl-compositor_agldemo.inc', '', d)}
