require agl-ivi-demo-flutter-guest-tradeshow.bb

SUMMARY = "AGL KVM + gateway demo tradeshow guest IVI Flutter image"

KUKSA_CONF = "kuksa-conf-gateway-demo"
