IMAGE_INSTALL:append = " \
    linux-firmware-rtl8822 \
    linux-firmware-rtl-nic \
    linux-firmware-mali-csffw-arch108 \
"
