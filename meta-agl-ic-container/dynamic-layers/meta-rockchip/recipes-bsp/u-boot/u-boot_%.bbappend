NONFITDT:aglcontainerguest = ""
UBOOT_EXTLINUX:aglcontainerguest = ""
UBOOT_EXTLINUX_ROOT:aglcontainerguest = ""
UBOOT_EXTLINUX_FDTDIR:aglcontainerguest = ""
UBOOT_EXTLINUX_FDT:aglcontainerguest = ""
UBOOT_EXTLINUX_CONSOLE:aglcontainerguest = ""
UBOOT_EXTLINUX_KERNEL_ARGS:aglcontainerguest = ""
UBOOT_EXTLINUX_KERNEL_IMAGE:aglcontainerguest = ""
UBOOT_EXTLINUX_LABELS:aglcontainerguest = ""
